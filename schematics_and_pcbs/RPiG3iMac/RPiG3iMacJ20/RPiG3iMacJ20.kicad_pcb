# Repository qbancoffee/imac_g3_ivad_board_init

File README.md (part):

# Add custom boards to an iMac G3 DV(slot loader) in order to use it as a monitor without having to destroy it.

See the wiki for an explantion of how this was done.<BR>

<H2>Wiki explaining how this was done.</H2>
 
- [Wiki explaining how this was done.](https://github.com/qbancoffee/imac_g3_ivad_board_init/wiki)

If you have a dead logic board but a functioning CRT then these boards can let you use your
iMac G3 DV as a VGA monitor so that you can use a modern desktop with it. You can even hand wire the 
whole thing without the need for the boards if you so wish.

Even if you have a perfectly functional iMac G3 DV you can remove your logic board and use these boards
to convert your iMac G3 DV into a VGA monitor without harming your iMac G3 and when you want your iMac back, you can remove the custom boards and plug your original logic board back in and still use your iMac G3 as an original apple product.
These boards are designed to plug right in without having to modify the case and attached things.

However....

# --->DO THIS AT YOUR OWN RISK<--- as things may break as you dissasemble your iMac and you can get shocked.

Although low risk, things can always go wrong, so be careful.

- The inner bezel is extremely fragile and routintely breaks.
- The CRT can hold a charge and shock you even if the iMac is not plugged in.
- Static discharge from your hands can destroy electronics so "GROUND THYSELF"

 I've documented much of the iMac G3 slot loader chasis connector pinouts on this repo and used 
 it as a guide to make breakout circuit boards than can plug right into the chassis connectors and provide
 standard connections so that a regular computer can use things like the CRT,speakers, power button, audio
 jacks, the down-converter board ect..
 
 It wasn't easy but luckily a lot of people have shared their findings online..
 
 There is working code here for both the arduino and raspberry pi to initialize the IVAD board so that you can use it as a monitor.
 
The current initialization sketch waits for button presses on an arduino pin to send the initialization sequence
to the IVAD board but you can just uncomment "initIvadBoard();" in "setup()" to send it as soon as it's powered.

</br>

Also, you might have to modify values in the init sequence to get the brightness, contrast and screen geometry
just right for your setup. below is an example from the init sketch.

```
  writeToIvad( 0x46, 0x04, 0x80);//red x-30
  writeToIvad( 0x46, 0x05, 0xB0);// green x
  writeToIvad( 0x46, 0x06, 0x78); //blue x-38

  writeToIvad( 0x46, 0x07, 0xB1); //horizontal position
  writeToIvad( 0x46, 0x08, 0xF8); //vertical size
  ```

<!-- toc -->
- [Success stories](#Success-Stories)
- [Goals](#Goals)
- [Chassis Connectors and Pinouts](#Chassis-Connectors-and-Pinouts)
    * [Removing the logic board](#Removing-the-logic-board)
- [Wiring VGA cable](#Wiring-VGA-cable)
    * [Making the cable](#Making-the-cable)
- [Preparing the Raspberry Pi](#Preparing-the-Raspberry-Pi)
    * [What to install](#What-to-install)
    * [Configure Resolution and Refresh Rate](#Configure-Resolution-and-Refresh-Rate)
-   * [Wiring The Raspberry Pi and testing the connection](#Wiring-The-Raspberry-Pi-and-testing-the-connection)
- [Wiring Arduino Uno](#Wiring-Arduino-Uno)
- [Wiring Arduino Nano](#Wiring-Arduino-Nano)
    * [Loading and Running the initialization sketch](#Loading-and-Running-the-initialization-sketch)
- [Wiring Arduino Uno to transmit EDID](#Wiring-Arduino-Uno-to-transmit-EDID)
- [Wiring Arduino Nano to transmit EDID](#Wiring-Arduino-Nano-to-transmit-EDID)
- [Powering the down converter board PAV](#Powering-the-down-converter-board-PAV)
- [Powering the CRT on and off](#Powering-the-CRT-on-and-off)
- [See Also](#See-Also)
   * [See the boards](#Boards)
   * [Getting adapter boards](#Ordering-Boards)
   * [Acknowledgements](#Acknowledgements)
   * [Videos](#Videos)
## Success Stories
- [Apple IIe using the iMac G3 as a monitor](https://www.reddit.com/r/VintageApple/comments/fox7b8/my_half_retro_battle_station/)
- [Apple IIe using the iMac G3 as a monitor 2 ](https://old.reddit.com/r/VintageApple/comments/fmoi5d/slot_loading_imac_g3_vga_input_hack/)
- [oshimai running windows on a pc104 computer](https://vimeo.com/415301897)
- [oshimais' repo with links to videos](https://github.com/shuuryou/imacg3)
- [A Nintendo Switch connected to an iMac G3](https://www.reddit.com/r/crtgaming/comments/k3hf02/imac_g3_crt_connected_to_switch/)
- [Check out the iMacSTer repo by wikerwaka it's impressive!](https://github.com/wickerwaka/iMacSTer)
- [Wikerwaka testing the iMacSTer](https://youtu.be/8O5fEVcCo0Q)
- [Wikerwaka assembling the iMacSTer](https://youtu.be/OmDPnWWWzPM)
- [Matt Gray upgrades an iMac G3 it and now runs on Apple silicon!](https://youtu.be/WoYBuP4Bxiw?si=AiPPqQjk6-E3-r2k)

## Goals

The main goal is to convert the iMac G3 into a VGA monitor whithout sacrificing the original CRT and
using as much of the iMac as possible. The difficult part is tricking the IVAD board into thinking it is 
still connected to a G3 logic board. the idea is to capture the init sequence and reimplement it using
a microcontoller like an arduino.

Once achieved, one can connect a standard computer to it as if it were a regular monitor with speakers.
One can even include a motherboard on the inside of the G3 basically converting it into a modern computer.

Here are the goals

- [x] Capture IVAD board initialization sequence from the Imac logic board to the IVAD board and implement with mcu & rpi.
- [x] Document how to control brightness, contrast, screen goemetry ect via the i2c lines.
- [x] Document as much of the pinouts as possible on the the chassis connectors .
- [x] [Design circuit boards that will plug into the connectors and allow one to use the on/off button,
speakers, power LED, mic ect..](#Boards)
- [x] Design the circuit boards with through hole components so that anyone can build these with just a soldering iron and
solder.
- [x] Use the original down-converter board(kind of like a power supply) to power things like
an amplifier and a slot loading DVD drive.

## Chassis Connectors and Pinouts

### Removing the logic board
The connector drawings in the above [diagram](#Chassis-Connectors-and-Pinouts) represent the cables
coming from the CRT analog board that plug into the logic board. To expose these, the logic board must
be removed.

## Wiring VGA cable

### Making the cable
This is perhaps the most time consuming part of the whole process because not all VGA cables are made the same so the colors for the cable I used may not be the colors used in your cable. Here are the steps I took.<br>

- Find a VGA cable to cut.
- Cut the cable so that you have at least one of the ferrite chokes left on the cable.
- Cut away the cable jacket such that the wires are at a comfortable handling length. 3 to 4 inches
- Strip each wire and ring them out to find what color corresponds to each pin on the DE15 connector.
- Use the [diagram](#Wiring-VGA-cable) above and map your cable to J20 using the DE15 pin numbers as the key.
- Option 1 ,use a 20 pin header and solder the DE15 wires to it then plug it into J20.
- Option 2, cut the required wires from J20 and splice them with VGA cable. Solder and use shrink tubing if you can but twisting them and electrical tape works as well. Make sure to leave enough wire on J20 in the event you need to reattach the wires.

## Preparing the Raspberry Pi

### What to install
- Install the latest raspian image using a regular monitor.
- Connect to your network and get the ip address for the pi by opening a terminal and issuing the following.
```bash
ifconfig
```
If you connected using wifi then the ip address is under wlan0: , inet.<br>
If you connected using a cable the the ip adress is under eth0: inet<br>
- Enable ssh , you'll need this to login from another computer when you don't have a display.
- Enable I2C.
- Install i2c-tools & git.
- ssh to the pi from a terminal if your on a Mac or linux. If you're on Windows use putty to ssh to the pi I'm assuming
the username is "pi" but replace this with the the username you've created for the pi.

```bash
sudo apt-get update && sudo apt-get -y install i2c-tools git
```
- Install smbus and RPI.GPIO for python using pip for the python version you have.
```bash
sudo pip install smbus RPI.GPIO
```
- Clone the iMac IVAD init repo
```bash
git clone https://github.com/qbancoffee/imac_g3_ivad_board_init.git
cd imac_g3_ivad_board_init
```
- Copy init_ivad.py to /usr/local/bin & and make it executeable
```bash
sudo cp init_ivad.py /usr/local/bin
sudo chmod +x /usr/local/bin/init_ivad.py
```
- Edit rc.local and add the script. Make sure it's added to the line before "exit 0 " or it will not run.
It also needs to be made executable since by default it doesn't do anything.
```bash
sudo nano /etc/rc.local
```

- It should look something like this
```
#!/bin/sh -e
#
# rc.local
#
# This script is executed at the end of each multiuser runlevel.
# Make sure that the script will "exit 0" on success or any other
# value on error.
#
# In order to enable or disable this script just change the execution
# bits.
#
# By default this script does nothing.

# Print the IP address
_IP=$(hostname -I) || true
if [ "$_IP" ]; then
  printf "My IP address is %s\n" "$_IP"
fi

/usr/local/bin/init_ivad.py

exit 0

```

- Ctrl-x to save and exit

- Make rc.local executable
```bash
sudo chmod +x /etc/rc.local
```

### Configure Resolution and Refresh Rate
- Edit config.txt
```bash
sudo nano /boot/config.txt
```
- The newer Raspberry Pi OS uses the VC4 V3D driver that causes the video to go blank. Comment the line that enables it and add the Fake VC4 V3D driver.
```
# Enable DRM VC4 V3D driver
#dtoverlay=vc4-kms-v3d
dtoverlay=vc4-fkms-v3d

```
Newer versions of the Raspberry Pi OS will ignore video modes specified in /boot/config.txt if the EDID sent from the monitor is corrupt or missing. Since we are not sending EDID information to the raspberry pi from the iMac we need to tell the OS to ignore the EDID and set the correct video mode.
- Add the following to the bottom of the file and save.
```
#iMac G3 settings
hdmi_ignore_edid=0xa5000080
hdmi_group=2
hdmi_mode=18
```
Here is a video where I perform the above steps.
- [Modding an iMac G3 DV using only a Raspberry Pi](https://youtu.be/xSiqchucFE4)
### Wiring The Raspberry Pi and testing the connection

In all cases, the IVAD board needs to be initialized when the power analog board is
turned on for the first time. To do this, the initialization sequence must be sent using the
I2C lines(SDA & SCL) on the Raspberry Pi's GPIO header. Connect the I2C lines according to the diagram
above and connect the VGA cable to the HDMI port using a HDMI to VGA converter.

- Use i2cdetect to probe the IVAD board. Make sure the iMac is plugged in, it does not have to be turned on for this.

```bash
i2cdetect -y 1
```
- Confirm it found address's 46 and 53, if no luck, check the wiring and make sure I2C is enabled. The output should look something like the following.
```    
     0  1  2  3  4  5  6  7  8  9  a  b  c  d  e  f
00:          -- -- -- -- -- -- -- -- -- -- -- -- -- 
10: -- -- -- -- -- -- -- -- -- -- -- -- -- -- -- -- 
20: -- -- -- -- -- -- -- -- -- -- -- -- -- -- -- -- 
30: -- -- -- -- -- -- -- -- -- -- -- -- -- -- -- -- 
40: -- -- -- -- -- -- 46 -- -- -- -- -- -- -- -- -- 
50: -- -- -- 53 -- -- -- -- -- -- -- -- -- -- -- -- 
60: -- -- -- -- -- -- -- -- -- -- -- -- -- -- -- -- 
70: -- -- -- -- -- -- -- --
```
- [Turn on the monitor](#Powering-the-CRT-on-and-off) and run the initialization script.The iMac should make
a nice old school "CRT IS ON"  sound. 
```bash
/usr/local/bin/init_ivad.py
```
If there are errors, make sure the iMac is plugged in and check the wiring.<br>
If there are no errors and there is nothing on the screen, move the mouse or press a key.
The raspberry pi might have turned off the display due to inactivity.

- With the IVAD initialized, Reboot the Raspberry Pi.

## Wiring Arduino Uno

## Wiring Arduino Nano

### Loading and Running the initialization sketch
write here

## Wiring Arduino Uno to transmit EDID

## Wiring Arduino Nano to transmit EDID

## Powering the down converter board PAV

The CRT analog board provides 24v AC to the PAV or down converter board through the logic board via the J22 
connector. you can directly connect the PAV board and the analog board through the J22 connector and
the PAV board will produce the typical mother board volytages. +12v, +5v +3.3v ect...

## Powering the CRT on and off

## See Also
### Boards
# J20 Board
What it does.
- detects button presses
- sends the init sequence to the IVAD boar
- sends the "turn-on" signal to the down-converter board
- has a control line "PROT" that when 5 volts are applied turns everythin off. A shut-off signal can be sent here.
- powers the green LED
- sends EDID information via VGA cable so that a connected computer knows how to configure the monitor for use.
</br>

This board works but as of March 23 2020 it needs a slight modification to make it more robust.
# Rendition

# Board installed

</br>

# Rendiiton of Rev 2 of the J20 board.

</br>

# J22 Board
What it does.
- provides access to the microphone and the speakers
- provides access to the power button
- provides access to the green LED
- provides access to the amber LED
- provides access to the headphone jacks 
- routes 24 VAC from the analog(CRT) board to the the down converter break out board.
</br>

This board has been tested and mostly worked. I found that the mic was miswired
but I've since fixed that.

</br>
# Down-converter breakout board
What it does
- provides a 24 VAC input from the J22 board into the down-converter board
- provides a "turn-on" input for the J20 board, this is DCO, which stands for Down Converter On
- provides 3.3 VDC out from the down-converter board that turns on and off with the CRT.
- provides   5 VDC out from the down-converter board that turns on and off with the CRT.
- provides  12 VDC out from the down-converter board that turns on and off with the CRT.
- provides a constant  8 VDC standby voltage when all is off and 12 VDC when all is on.
- provided a constant 15 VDC standby voltage when all is off and 24 VDC when all is on.
</br>
The down-conveter uses the 24 VAC coming from J22 in order to power the original logic board and drives. Some people have called this the iMac G3 power supply. This is what it looks like.

</br>
# Rendition

</br>
# Actual Board

</br>
# Board installed

</br>

### Ordering Boards
All PCB manufacturers should accept gerber files to manufacture boards so I've decided
to design these in KiCAD which is suite of open source EDA programs to create schematics and
design PCBs. There are no limitations to the size of the board and you don't have to order from
a specific vendor.

Recently I've been using https://jlcpcb.com/ and the turn arounds are fast for the price.
In the "schematics_and_pcbs" folder are the three kicad projects for each board, each in its own folder.
I've included the gerber files and zipped them up for convenience, they are in the gerber directory
for each project. To order you can just upload the zip file to https://jlcpcb.com/ or whatever company you choose
and you should get them in the mail. There is a bill of materials included in each project folder. It's a csv file
that includes the reference number, the part number and vendor so you can order the componets to build the boards.
I like to buy from digikey but obviously you can find a vendor that fits your needs.

### Acknowledgements

- [patriciooholegu for inspiring me to do this with an eMac](https://forums.macrumors.com/threads/i-have-decided-to-hack-emacs-crt-to-work-with-any-standard-motherboard.1754089/post-19353472)
- [ym58 for providing the video connector wiring.](https://www.tonymacx86.com/threads/imac-g3-slot-mod-video-connector.125515/)
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
## KiCad design schematics_and_pcbs/RPiG3iMac/RPiG3iMacJ20/RPiG3iMacJ20.kicad_pcb

File schematics_and_pcbs/RPiG3iMac/readme.txt:

These boards were created and graciously contributed by Rudy https://reng.ca for
this project for others to use.

RPiG3iMac       Contains the KiCAD project files for a Raspberry Pi HAT
                with power and activity LEDs. The HAT also converts the
                incoming TTL RS232 signal to CMOS levels for use by the
                built in serial port.
            
RPiG3iMacJ20    Contains the KiCAD project files for a breakout board
                for the J3 and J5 headers on the J20 board. Once mounted
                one can connect regular wires via a terminal strip to
                interface with the two headers

Parts:
D1, D2, D3: LED; LED_0603_1608Metric
J1, J2: Conn_02x03_Odd_Even; Harwin_M20-7810345_2x03_P2.54mm_Vertical
J3: Screw_Terminal_01x05; TerminalBlock_Phoenix_MPT-0,5-5-2.54_1x05_P2.54mm_Horizontal
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1: 470; R_0603_1608Metric
R2, R3: 220; R_0603_1608Metric

Connections:
+5V: D1.2 (A), J1.5
GND: J1.1, J3.3, R1.2, R2.2, R3.2
unnamed: D1.1 (K), JP1.1 (A)
unnamed: D2.1 (K), R2.1
unnamed: D2.2 (A), J2.4, J3.4
unnamed: D3.1 (K), R3.1
unnamed: D3.2 (A), J2.6, J3.5
unnamed: J2.3, J3.1
unnamed: J2.5, J3.2
unnamed: JP1.2 (B), R1.1

Board: 2 copper layers, 19.7 x 17.8 mm, 10 parts (0 on the bottom side), 10 nets.

## KiCad design schematics_and_pcbs/RPiG3iMac/RPiG3iMac/RPiG3iMac.kicad_pcb

File schematics_and_pcbs/readme.txt:

These are the KiCAD project files for this project.

===Main boards===

-imac_g3_333mhz_slot_loading_J20_adapter_board
	This board is the "brains" of the operation, it sends the init sequence
	to the IVAD board and also sends EDID information to any device that
	requests it when conencted to the VGA port.
 
-imac_g3_down_converter_board_adapter
	This board takes 24VAC from the analog board via the the J22 board and
	converts it to standard computer power supply voltages. +12VDC, +5VDC
	and +3.3VDC. This board also has a footprint to include a connector
	to connect a CPU fan.
	
-imac_g3_slot_loading_J22_adapter_board
	This board is essentially a breakout board that allows one to use the 
	built in speakers, power switch, leds and 24VAC.

-surfacemount_version	
	This will be a surface mount version of the original main boards.
	It is currently under development. The idea is to have boards
	that can be assembled by an assembly outfit to bring down the cost.
	
===User contributed boards==

-RPiG3iMac	
	Additional KiCAD projects for a Raspberry Pi Hat and a breakout board
	for the J20 board. These boards were contributed by Rudy https://reng.ca
	, look inside the directory for more details.

Parts:
C1: 10uF 25V; C_0603_1608Metric
C2, C3: 22uF 10V; C_0603_1608Metric
D1: 40V 3A; D_SMB
D2: 12VDC; LED_0603_1608Metric
D3: 5VDC; LED_0603_1608Metric
D4: FAN; LED_0603_1608Metric
D5, D6, D7: 100V 150mA; D_SOD-123
D8, D9, D10: 3.3VDC; LED_0603_1608Metric
J1: 12VDC IN; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J2: RPi; Harwin_M20-7812045_2x20_P2.54mm_Vertical_rpi
J3: SERIAL TO iMAC G3 J20 BOARD; TerminalBlock_Phoenix_MPT-0,5-5-2.54_1x05_P2.54mm_Horizontal
J4: FAN; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J5: 5VDC OUT; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J6: 3.3V DC OUT; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J7: RPi POE Header; PinHeader_2x02_P2.54mm_Vertical
JP1: GPIO23 PWR STATUS; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: GPIO24 TO FAN; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: 5VDC; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4: 12VDC; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1: BC817; SOT-23
R1: 1K0; R_0603_1608Metric
R2, R3: 2K0; R_0603_1608Metric
R4, R6: 470; R_0603_1608Metric
R5, R7, R8, R9: 220; R_0603_1608Metric
RV1: 5M0; Potentiometer_Bourns_3296Y_Vertical
U1: RPM5.0-3.0; Converter_DCDC_RECOM_RPMx.x-x.0

Connections:
+3V3: C3.1, D8.2 (A), J2.1 (3V3), J2.17 (3V3), J6.1
+5V: C2.1, D3.2 (A), J2.2 (5V), J2.4 (5V), J5.1, JP3.1 (A), U1.A5 (+VOUT), U1.B5 (+VOUT), U1.C5 (Sense)
+12V: C1.1, D1.1 (K), D2.2 (A), JP4.1 (A), U1.A1 (+VIN), U1.A2 (+VIN)
/PB0_FROM_J20: D9.2 (A), J2.36 (GPIO16), J3.4
/PB1_FROM_J20: D10.2 (A), J2.37 (GPIO26), J3.5
/RX_FROM_J20: J2.8 (GPIO14/TXD), J3.2
/TX_FROM_J20_(5V): J3.1, R1.1
GND: C1.2, C2.2, C3.2, J1.2, J2.6 (GND), J2.9 (GND), J2.14 (GND), J2.20 (GND), J2.25 (GND), J2.30 (GND), J2.34 (GND), J2.39 (GND), J3.3, J5.2, J6.2, Q1.2 (E), R2.2, R3.2, R4.2, R5.2, R7.2, R8.2, R9.2, RV1.3, U1.A3 (GND), U1.A4 (GND), U1.B1 (GND), U1.B2 (GND), U1.B3 (GND), U1.B4 (GND), U1.C2 (GND), U1.C3 (GND), U1.C4 (GND), U1.D2 (GND), U1.D3 (GND), U1.D4 (GND), U1.D5 (GND), U1.E3 (GND), U1.E4 (GND)
unnamed: D1.2 (A), J1.1
unnamed: D2.1 (K), R3.1
unnamed: D3.1 (K), R4.1
unnamed: D4.1 (K), R5.1
unnamed: D4.2 (A), JP2.1 (A), R6.2
unnamed: D5.1 (K), D6.1 (K), D7.1 (K), J4.1
unnamed: D5.2 (A), JP3.2 (B)
unnamed: D6.2 (A), JP4.2 (B)
unnamed: D7.2 (A), J4.2, Q1.3 (C)
unnamed: D8.1 (K), R7.1
unnamed: D9.1 (K), R8.1
unnamed: D10.1 (K), R9.1
unnamed: J2.10 (GPIO15/RXD), R1.2, R2.1
unnamed: J2.16 (GPIO23), JP2.2 (B)
unnamed: J2.18 (GPIO24), JP1.2 (B)
unnamed: JP1.1 (A), U1.D1 (PGood)
unnamed: Q1.1 (B), R6.1
unnamed: RV1.2, U1.E5 (Trim)

Board: 2 copper layers, 65.0 x 56.5 mm, 40 parts (0 on the bottom side), 26 nets.

Other parts of the board:
 : MountingHole_3mm
 #2,  #3,  #4: MountingHole_3mm

## KiCad design schematics_and_pcbs/surfacemount_version/imac_g3_333mhz_slot_loading_J20_adapter_board/imac_g3_333mhz_slot_loading_J20_adapter_board.kicad_pcb

Board: 2 copper layers, 82.5 x 52.5 mm, 31 parts (1 on the bottom side), 38 nets.

Parts:
C1, C2: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4, C5, C6: 100uF 6.3V; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
D1, D2, D3: D_Schottky_ALT; D_SOD-123
H1, H2: MountingHole_Pad; MountingHole_3.5mm_Pad
J1: Screw_Terminal_01x06; TerminalBlock_Phoenix_PT-1,5-6-5.0-H_1x06_P5.00mm_Horizontal
J2: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J3, J5: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J4: DB15_Female_HighDensity; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset8.35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
J6: USB_B_Micro; USB_Mini-B_Wuerth_65100516121_Horizontal
JP1, JP2, JP3: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2, R3, R6: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U2, U3: CPC1972GSTR; DIP-6_W7.62mm_SMDSocket_SmallPads
U4: CH340G; SOIC-16_3.9x9.9mm_P1.27mm
Y1: 16 Mz cystal; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
/5V_TRICKLE: C3.1, C4.1, C5.1, C6.1, D1.2, J2.6, J3.2, R1.2, R3.1, R5.1, U3.4
/5V_USB: D3.2, J6.1, U4.16
/-10V: J1.3, J2.8
/BLUE: J2.13, J4.3
/COMPUTER_5V: D2.2, J4.9
/COMPUTER_SCL: J5.2, JP2.2, U1.28
/COMPUTER_SDA: J5.1, JP1.2, U1.27
/DCO: J1.5, J2.5
/GREEN: J2.15, J4.2
/H_SYNC: J2.9, J4.13
/IVAD_SCL: J2.2, U1.9
/IVAD_SDA: J2.1, U1.2
/LINE_SENSE: J1.2, J2.19
/LPIACT:L1_LP: J1.6, J2.10, J2.12, U2.4, U3.6
/MISO: J3.1, U1.16
/MOSI: J3.4, U1.15
/PB0: J5.4, U1.12
/PB1: J5.6, U1.13
/PROT: J1.4, J2.7, R2.2
/PWR_BTN: J1.1, R1.1, U1.1
/RED: J2.17, J4.1
/SCK: J3.3, U1.17
/SERIAL_RX: J5.3, U1.30, U4.2
/SERIAL_TX: J5.5, U1.31, U4.3
/V_SYNC: J2.11, J4.14, JP3.2
/~RESET: J3.5, R3.2, U1.29
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, H1.1, H2.1, J2.3, J2.4, J2.14, J2.16, J2.18, J2.20, J3.6, J4.5, J4.6, J4.7, J4.8, J4.10, J6.5, J6.6, R2.1, R4.1, R6.1, U1.3, U1.5, U1.21, U2.6, U4.1, Y1.2, Y1.4
unnamed: C1.2, U1.7, Y1.1
unnamed: C2.1, U1.8, Y1.3
unnamed: D1.1, D2.1, D3.1, U1.4, U1.6, U1.18
unnamed: J4.12, JP1.1
unnamed: J4.15, JP2.1
unnamed: J6.2, U4.6
unnamed: J6.3, U4.5
unnamed: JP3.1, U1.14
unnamed: R4.2, U3.2
unnamed: R5.2, U2.1
unnamed: R6.2, U1.11, U2.2, U3.1

## KiCad design schematics_and_pcbs/imac_g3_slot_loading_J22_adapter_board/imac_g3_slot_loading_J22_adapter_board.kicad_pcb

Board: 2 copper layers, 65.0 x 30.0 mm, 12 parts (4 on the bottom side), 23 nets.

Parts:
C1: 1uF; CP_Radial_D4.0mm_P1.50mm
H1: MountingHole_Pad; MountingHole_3.5mm_Pad
J1: Conn_02x13_Odd_Even; PinHeader_2x13_P2.54mm_Vertical
J2: Screw_Terminal_01x10; TerminalBlock_Phoenix_PT-1,5-10-5.0-H_1x10_P5.00mm_Horizont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
J3: AudioJack3; Jack_3.5mm_CUI_SJ1-3533NG_Horizontal_CircularHoles
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
JP1, JP3: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
/+AC: J1.24, J1.26, J2.1
/+AMBER_LED: J1.20, R2.2
/+GREEN_LED: J1.19, JP3.1, R1.2
/+LEFT_SPEAKER: J1.14, J2.8
/+MICROPHONE: J1.3, JP2.2
/+RIGHT_SPEAKER: J1.13, J2.10
/-AC: J1.23, J1.25, J2.2
/-LEFT_SPEAKER: J1.16, J2.7
/-RIGHT_SPEAKER: J1.15, J2.9
/HEADPHONE_1_LEFT: J1.10, J4.6
/HEADPHONE_1_RIGHT: J1.9, J4.5
/HEADPHONE_1_SENSE: J1.8, J4.4
/HEADPHONE_2_LEFT: J1.6, J4.2
/HEADPHONE_2_RIGHT: J1.5, J4.1
/HEADPHONE_2_SENSE: J1.7, J4.3
/MICROPHONE_POWER: J3.R, JP3.2, R3.2
/POWER_BUTTON: J1.17, J2.4
GNDREF: H1.1, J1.1, J1.2, J1.4, J1.11, J1.18, J2.6, J3.S
unnamed: C1.1, J3.T, JP2.3
unnamed: C1.2, JP1.2, JP2.1
unnamed: J2.3, R1.1
unnamed: J2.5, R2.1
unnamed: JP1.1, R3.1

## KiCad design schematics_and_pcbs/imac_g3_down_converter_board_adapter/imac_g3_down_converter_board_adapter.kicad_pcb

Board: 2 copper layers, 88.0 x 39.0 mm, 8 parts (0 on the bottom side), 13 nets.

Parts:
H1: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1: Screw_Terminal_01x10; TerminalBlock_Phoenix_PT-1,5-10-5.0-H_1x10_P5.00mm_Horizont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
J2: Screw_Terminal_01x04; TerminalBlock_Phoenix_PT-1,5-4-5.0-H_1x04_P5.00mm_Horizontal
J7: Conn_02x12_Top_Bottom; Molex_Micro-Fit_3.0_43045-2400_2x12_P3.00mm_Horizontal
JP1: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
M1: Fan_Tacho_PWM; FanPinHeader_1x04_P2.54mm_Vertical
TP1, TP2: TestPoint; TestPoint_Plated_Hole_D2.0mm

Connections:
/+3.3V: J1.7, J1.8, J7.1, J7.18, J7.19, J7.20, J7.21
/+5V: J1.5, J1.6, J7.14, J7.15, J7.24, JP1.3
/+8V_STANDBY_+12V_ON: J1.9, J7.22
/+12V: J1.3, J1.4, J7.13, JP1.1
/+15V_STANDBY_+24V_ON: J1.10, J7.12
/+AC: J2.4, J7.10, J7.11
/-AC: J2.3, J7.8, J7.9
/DCO: J2.1, J7.5
/GND: H1.1, J1.1, J1.2, J7.2, J7.3, J7.6, J7.7, J7.16, J7.17, J7.23, M1.1
/PT: J2.2, J7.4
/PWM: M1.4, TP2.1
/TACHO: M1.3, TP1.1
unnamed: JP1.2, M1.2

## Commit log

2020-01-27 hand tweaked the initialization code a to balance RGB and increase brightness
2020-02-01 added image that contains some pinouts
2020-02-01 Update README.md
    added connectors and pinout images
2020-02-01 added i2c initialization script to run on the raspberry pi
2020-02-01 added vga cable pinout
2020-02-01 Update README.md
    added VGA cable diagram
2020-02-01 updated vga cable image
2020-02-01 added raspberry pi wiring
2020-02-01 added borders to images
2020-02-01 added more drawings
2020-02-01 added diagrams to connects arduinos to transmit EDID info
2020-02-01 fixed image issue
2020-02-02 added diagram to turn crt on and off
2020-02-02 added tab to connector drawing to use as a reference
2020-02-02 added tabs to j20
2020-02-02 Create LICENSE
    adding a license
2020-02-03 modified the arduino sketch to use transistors instead of relays to power the iMac on and off
2020-02-04 started putting together a schematic to connect to the chassis connectors
2020-02-07 added pav board pinout and updated J22 pins
2020-02-07 added minus to words
2020-02-07 rotated pav image
2020-02-07 updated db15 to de15
2020-02-07 fixed mispelled chasis to chassis...
2020-02-07 updated some pins on J20
2020-02-08 added images of parts that I need
2020-02-10 updated pniout names
2020-02-10 reordered pinout names in even and odd columns for better readability
2020-02-10 improved readability
2020-02-13 removed some incorrect instructions from the image
2020-02-14 updated schematic with new J20 info
2020-02-17 added second initialization script
2020-02-18 updated diagrams with headphone jack pinout and correcected ground swap
2020-02-24 I confirmed that the second capture of the initialization sequence works with both of my iMacs so there is no need to keep two copies. I replaced the first one with the second one.
2020-02-24 made a test pcb
2020-03-02 made board a little curvier
2020-03-03 made more changes to the board
2020-03-04 added caps to the board
2020-03-06 added rev-1 finshes. this is the board I ordered
2020-03-10 updated pinouts to reflect mic connections
2020-03-14 added J22 board design
2020-03-14 added gerber zip file
2020-03-14 added BOM
2020-03-22 updated pin assigments on down-converter board to reflect those assigned by the manufacturer
2020-03-22 fixed pin assignment error in drawing
2020-03-22 added a reference to the J20 connector
2020-03-23 added schematics and pcb for down converter board
2020-03-26 fixed miswired microphone jack
2020-03-27 updated sketch to iclude two init sequences and code to detect button presses
2020-03-27 added edid simulator to send edid information to a computer
2020-03-27 added edid.bin, a binary that has the edid for the iMac G3 slot loader
2020-03-27 moved images into an images folder
2020-03-27 added down converter board image
2020-03-27 added border to image
2020-03-27 added some images
2020-03-29 removed an atmega328 and moved VGA connector
2020-03-29 added J20 board rev2 image
2020-03-29 combined edid sketch and init sketch
2020-03-29 updated sketch for use with the J20 board rev 2
2020-03-29 added resistor values to silkscreen
2020-03-30 added electrek mic circuit stuff
2020-03-31 created BOMs and updated crystal caps
2020-04-05 added down converter breakout board images
2020-04-07 updated silkscreen to make it more readable
2020-04-08 added a third init sequence
2020-04-08 added pdf version of the schematics
2020-04-09 fixed name
2020-04-09 updated schematic
2020-04-09 adjustment functions
2020-04-09 byte -> int
2020-04-09 serial interface
2020-04-10 uploaded correct schematic
2020-04-10 adapted anotherelise's monitor properties code to the sketch
2020-04-10 converted all ints to bytes to take up less memory and to make it easier to save to
2020-04-11 created ivad.h and placed constants in there and reduced number of mehtods
2020-04-12 added the three edid's provided by user oshimai
2020-04-12 finer adjustment values
    p command to print current value indexes
2020-04-12 added captures and edids contributed by users
2020-04-12 added elises raw init capture
2020-04-12 added extra edids provided by oshimai
2020-04-13 added edid extracted by oshimai
2020-04-13 added edid files to raw_data folder
2020-04-14 added beta version of the gui based monitor settings
2020-04-14 turns out you can make it brighter than mac os 9s control panel will allow
2020-04-14 added rockyhill raw capture and sparpet raw capture
2020-04-15 modified sketch to increment nd decrement property values instead of referencing an array because the compiler was complaining about possible corruption because of low memory
2020-04-16 implemented vsync monitoring to shut off computer
2020-04-17 updated schematic with a VSYNC detect input line.
2020-04-18 added a new initialization sequence and a capture when the computer balnks the screen and wakes
2020-04-28 Update ivad.h
    added an edid by oshimai
2020-05-11 added service manual
2020-05-13 merged lots of code from oshimais sketch to make it compatible with his GUI
2020-05-14 added apple display adjustment capture files and updated ivad.h
2020-05-14 removed service manual
2020-05-14 added a description
2020-05-16 finally fixed the code to be compatible with both my gui and oshimais
2020-05-18 fized first boot check
2020-05-18 re-enabled vsync
2020-05-19 fixed cutoff constants names
2020-05-19 decoded some more of the init sequence
2020-05-19 made anotherelises' init sequence the working one and updated RESEVED6 variable
2020-05-21 added three more captures, shutdown sleep and wakeup
2020-07-09 added image of all three boards
2020-07-10 modified image
2020-07-10 added more images
2020-07-10 added text to chassis image
2020-07-10 added text to analog board
2020-07-10 added more text to the analog board pic
2020-07-10 added text to the logic board and down converter board imae
2020-07-10 added more text to images
2020-07-10 removed auto generted javadocs from display properties gui
2020-07-10 added trickle voltage rext to image
2020-07-12 added harness image
2020-08-09 added interactive bom's to help in the assembly process
2020-10-13 added diagram with some basic wiring
2020-10-29 added image for arduino isp
2021-03-18 added image of the usb to serial converter
2021-03-18 Updated the 26 pos header on the J22 board from a non stock item to a normally stocked item.
2022-02-22 Update imacG3IvadInit.ino
    Increased vsync_off_time from 5 seconds to 30 seconds
2022-03-20 Update imacG3IvadInit.ino
    Corrected comments as suggested by Rudy Boonstra.
2022-04-26 started putting together a surface mount version.
2022-04-26 added stl files for a raspberry pi 4 mount
2022-04-26 Added user contributed boards by Rudy. -A raspberry pi HAT -A breakout board for the headers on the J20 board.
2022-04-27 removed .DS files and zipped gerber files. Made some changes to some of he readme's
2023-08-27 fixed python spacing issue
2023-10-05 converted J20 board to SMD and sourced components for it.
2023-11-10 Add files via upload
    added waveform images
2023-12-20 Updated video config defaults to adjust color and screen size slightly.
2026-01-19 Fix typo in disassembly warning in README
    Corrected a typo in the warning message about disassembling the iMac.
2026-01-19 Fix typo in link description for Matt Gray's upgrade
