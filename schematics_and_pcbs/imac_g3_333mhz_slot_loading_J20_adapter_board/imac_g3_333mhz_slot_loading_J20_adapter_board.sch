File: schematics_and_pcbs/imac_g3_333mhz_slot_loading_J20_adapter_board/imac_g3_333mhz_slot_loading_J20_adapter_board.sch (KiCad schematic (older format))
At the start: 21 parts, among them J1 DB15_Female_HighDensity, J2 Screw_Terminal_01x06, J20 Conn_02x10_Odd_Even, U1 ATmega328-PU, U2 ATmega328-PU, U3 LCC110, Y1 Crystal, Y2 Crystal

Commit message: removed an atmega328 and moved VGA connector
Parts:
- removed C3, C4: 22pF, Capacitor_THT:C_Disc_D9.0mm_W5.0mm_P10.00mm, symbol Device:C
- removed C6: 470uF, Capacitor_THT:CP_Radial_D8.0mm_P3.50mm, symbol Device:CP
- removed U2: ATmega328-PU, Package_DIP:DIP-28_W7.62mm, symbol MCU_Microchip_ATmega:ATmega328-PU
- removed Y2: Crystal, Crystal:Crystal_HC49-U_Vertical, symbol Device:Crystal
- added H1: MountingHole_Pad, MountingHole:MountingHole_3.5mm_Pad, symbol Mechanical:MountingHole_Pad
- added J3, J5: Conn_02x03_Odd_Even, Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical, symbol Connector_Generic:Conn_02x03_Odd_Even
- added R2, R3: 10k, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol Device:R_Small_US
- C1, C2: value 22pF -> 20pF; footprint Capacitor_THT:C_Disc_D9.0mm_W5.0mm_P10.00mm -> Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm; Part# BC2364-ND -> 2368-90020-ND
- J2: renamed from J20; Part# 609-3206-ND -> SAM1068-10-ND
- R1: renamed from R2; Part# (none) -> CF14JT10K0CT-ND; Vendor (none) -> digikey
- R4: renamed from R1; Part# (none) -> CF14JT220RCT-ND; Vendor (none) -> digikey
- U1: Part# (none) -> ATMEGA328P-PU-ND; Vendor (none) -> digikey
- renumbered C5 to C3, H1 to H2, J2 to J1, J1 to J4, U3 to U2
Connections:
- net 5V_TRICKLE: now also J3.2 (Pin_2), R3.1; no longer U1.20 (AVCC), U1.7 (VCC)
- net COMPUTER_SCL: now also U1.28 (PC5), J5.2 (Pin_2)
- net COMPUTER_SDA: now also U1.27 (PC4), J5.1 (Pin_1)
- net GND: now also H1.1, J3.6 (Pin_6), R2.1
- net IVAD_SCL: now also U1.11 (PD5); no longer U1.28 (PC5)
- net IVAD_SDA: now also U1.6 (PD4); no longer U1.27 (PC4)
- net PROT: now also R2.2
- net PWR_BTN: now also U1.5 (PD3); no longer U1.19 (PB5)
- net ~RESET: now reaches U1.1 (~RESET~/PC6)
- net ~RESET: now also J3.5 (Pin_5), R3.2
- net PB0: now reaches U1.14 (PB0)
- net PB0: now also J5.4 (Pin_4)
- net PB1: now reaches U1.15 (PB1)
- net PB1: now also J5.6 (Pin_6)
- net MOSI: now reaches U1.17 (PB3)
- net MOSI: now also J3.4 (Pin_4)
- net MISO: now reaches U1.18 (PB4)
- net MISO: now also J3.1 (Pin_1)
- net SERIAL_RX: now reaches U1.2 (PD0)
- net SERIAL_RX: now also J5.3 (Pin_3)
- net SERIAL_TX: now reaches U1.3 (PD1)
- net SERIAL_TX: now also J5.5 (Pin_5)
- net at D1.1 (K), D2.1 (K): now also U1.20 (AVCC), U1.7 (VCC)
- new net SCK: J3.3 (Pin_3), U1.19 (PB5)
- no-connect marks 40 -> 11
Other:
- moved on the sheet: C1, D1, D2, J1, R1, R4, U1, U2, Y1

Commit message: created BOMs and updated crystal caps
Parts:
- C1, C2: value 20pF -> 22pF; Part# 2368-90020-ND -> 445-15973-ND
Changed lines of the file:
@@
 P 6300 2550
 F 0 "C1" H 6415 2596 50  0000 L CNN
-F 1 "20pF" H 6415 2505 50  0000 L CNN
+F 1 "22pF" H 6415 2505 50  0000 L CNN
 F 2 "Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm" H 6338 2400 50  0001 C CNN
-F 3 "https://www.nteinc.com/capacitor_web/pdf/90000.pdf" H 6300 2550 50  0001 C CNN
+F 3 " https://product.tdk.com/info/en/catalog/datasheets/leaddisc_commercial_cc45_en.pdf?ref_disty=digikey" H 6300 2550 50  0001 C CNN
 F 4 "digikey" H 6300 2550 50  0001 C CNN "Vendor"
-F 5 "2368-90020-ND" H 6300 2550 50  0001 C CNN "Part#"
+F 5 "445-15973-ND" H 6300 2550 50  0001 C CNN "Part#"
 	1    6300 2550
 	1    0    0    -1
@@
 P 6300 3950
 F 0 "C2" H 6415 3996 50  0000 L CNN
-F 1 "20pF" H 6415 3905 50  0000 L CNN
+F 1 "22pF" H 6415 3905 50  0000 L CNN
 F 2 "Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm" H 6338 3800 50  0001 C CNN
-F 3 "https://www.nteinc.com/capacitor_web/pdf/90000.pdf" H 6300 3950 50  0001 C CNN
+F 3 " https://product.tdk.com/info/en/catalog/datasheets/leaddisc_commercial_cc45_en.pdf?ref_disty=digikey" H 6300 3950 50  0001 C CNN
 F 4 "digikey" H 6300 3950 50  0001 C CNN "Vendor"
-F 5 "2368-90020-ND" H 6300 3950 50  0001 C CNN "Part#"
+F 5 "445-15973-ND" H 6300 3950 50  0001 C CNN "Part#"
 	1    6300 3950
 	1    0    0    -1
